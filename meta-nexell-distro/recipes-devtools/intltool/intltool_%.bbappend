DEPENDS_class-native = "libxml-parser-perl-native gettext-native"