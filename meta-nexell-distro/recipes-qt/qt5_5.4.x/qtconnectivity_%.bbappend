require qt5-nexell.inc

SRC_URI[md5sum] = "eed0685793fc39c4931c2ae6ac36ff52"
SRC_URI[sha256sum] = "3a9ec013b53ede86ff70d7a21c88ab19936dbee2ba22ea084c93479bcd5bee62"
