require qt5-nexell.inc

SRC_URI[md5sum] = "a868bd8605ed7fc11f4bb124fe525823"
SRC_URI[sha256sum] = "93f9926fa9241cd2ca2aa4e27394b10e7f360a4ae1368853535980e902a53f96"
