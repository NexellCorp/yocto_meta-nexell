require qt5-nexell.inc

SRC_URI[md5sum] = "42c13436b12468923eb86196072c9559"
SRC_URI[sha256sum] = "059660c259c40068835121c89094125770bd6a8aaa57263255c64b3b74cf74d9"
