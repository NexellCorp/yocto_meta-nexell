require qt5-nexell.inc

SRC_URI += " \
    file://0001-Initial-porting-effort-to-GStreamer-1.0.patch \
"

SRC_URI[md5sum] = "796b6a5a19c570c567b409a0efef8f30"
SRC_URI[sha256sum] = "946d86fdfb5ba9eadb9458d1920e591ef619efb731795213843bb260ae872e23"

