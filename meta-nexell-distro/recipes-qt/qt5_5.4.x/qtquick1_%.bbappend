require qt5-nexell.inc

SRC_URI[md5sum] = "35b90b0db13e855769a3f34a90f7dabb"
SRC_URI[sha256sum] = "9d055c6ba0dbfbd07c7d2ee65e90ca3ea0412a564cd68a4626a226171eac5919"
