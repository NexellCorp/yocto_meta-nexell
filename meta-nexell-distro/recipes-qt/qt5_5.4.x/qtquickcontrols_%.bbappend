require qt5-nexell.inc

SRC_URI[md5sum] = "d2ec5dca8cef8cc48149420c17e07a18"
SRC_URI[sha256sum] = "cc30c7c1e19e365bd362f2c5e9d68f5b0ed8ac9303d9099c5bae00ecee93ce52"
