require qt5-nexell.inc

SRC_URI[md5sum] = "12efdbcecfc4e93cfef2e193e5e368eb"
SRC_URI[sha256sum] = "43ad9947eb8ded628711965e4fea594ef52f53d4abb780dda44a1234819aea61"
