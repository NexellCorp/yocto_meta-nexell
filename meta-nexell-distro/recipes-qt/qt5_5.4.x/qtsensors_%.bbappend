require qt5-nexell.inc

SRC_URI[md5sum] = "d78f2c681b0b24a31dcb29ca20c2890e"
SRC_URI[sha256sum] = "c72e78270f37aca970668aea6bd38289b95e3797cea0f4793e76cce7109aa157"
