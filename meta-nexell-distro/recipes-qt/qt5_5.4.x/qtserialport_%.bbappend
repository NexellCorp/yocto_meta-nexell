require qt5-nexell.inc

SRC_URI += " \
    file://0001-Unix-Clear-serial_struct-instances.patch \
"

SRC_URI[md5sum] = "8fa03b70e8cd82cf3ff2efda92703156"
SRC_URI[sha256sum] = "2deb129c0d976a5861058ca1939facf4ee3d650268dd8fcd5c779bafd2b2657a"
