require qt5-nexell.inc

SRC_URI[md5sum] = "dbf365ea8d2d9233a527e92008776056"
SRC_URI[sha256sum] = "58051b7428cab24b2b769192617d66b2777072a2a72362109ba80d5ebd01ac46"
