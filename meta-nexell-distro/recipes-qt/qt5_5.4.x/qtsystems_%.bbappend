require qt5-nexell.inc

SRC_URI[md5sum] = "f639b8e0e5c8b66faed22015cdad7cb4"
SRC_URI[sha256sum] = "4e9608c3ec91bef2a4ee12187b0e59c6c4ec2b19db6615daeba35522207d4d83"
