require qt5-nexell.inc

SRC_URI[md5sum] = "3960f3cbf2b1012e2ca87ed48950be7c"
SRC_URI[sha256sum] = "b6e7f698f3b3f55b5ca91863b1ea21055cc25e77001535e1b275a01ff6683265"
