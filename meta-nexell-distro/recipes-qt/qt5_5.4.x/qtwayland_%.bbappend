require qt5-nexell.inc

SRC_URI += " \
    file://0001-examples-wayland-include-server-buffer-only-when-bui.patch \
"

SRC_URI[md5sum] = "3a9d0219388e3fb873cb463bc4f26734"
SRC_URI[sha256sum] = "9e191b748e39700eec0cd704f5bdf39333c253d5640a0461c6b3ff99a2592fec"