require qt5-nexell.inc

SRC_URI[md5sum] = "ee48695dbe225df4808c0e59154a95af"
SRC_URI[sha256sum] = "2f620efda9496fececcaefa63e7512f175e52398c912710a7d5aeecb2688a2bb"
