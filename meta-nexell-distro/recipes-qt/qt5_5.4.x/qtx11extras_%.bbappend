require qt5-nexell.inc

SRC_URI[md5sum] = "029bcc4f7064d965b7f0f71f01001683"
SRC_URI[sha256sum] = "3ff6ae24cf5f9b86ce776ebaddf845577a1bd6b19450425a21960177695cc251"
