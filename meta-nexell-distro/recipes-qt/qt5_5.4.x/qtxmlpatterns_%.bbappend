require qt5-nexell.inc

SRC_URI[md5sum] = "6c281b194e5f43cfcb68b2fff2ab2801"
SRC_URI[sha256sum] = "ce7c91d20f2a7e288c28f51e8c3c075f91e0f2280e3036bc8b33893fb3d4c355"
