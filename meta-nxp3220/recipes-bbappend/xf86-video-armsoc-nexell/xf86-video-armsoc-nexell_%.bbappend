FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI += " \
    file://0001-drmmode_nexell-hwcursor-api-none.patch \
"
