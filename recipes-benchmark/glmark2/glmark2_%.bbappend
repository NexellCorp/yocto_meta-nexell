PACKAGECONFIG_append_pn-glmark2 += "wayland-gles2 drm-gles2"
PACKAGECONFIG_remove_pn-glmark2 += "wayland-gl drm-gl x11-gl"