# Base this image on nexell-image-minimal
include nexell-image-tiny.inc
inherit nexell-post-process-avn-4418

LICENSE = "LGPLv2.1"
