# Base this image on nexell-image-minimal
require ../nexell-image-tiny.inc
inherit s5p4418-avn-ref-post-process

LICENSE = "LGPLv2.1"
