# Base this image on nexell-image-minimal
include nexell-image-tiny.inc
inherit s5p4418-cluster-ref-post-process

LICENSE = "LGPLv2.1"
