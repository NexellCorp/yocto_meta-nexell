# Base this image on nexell-image-minimal
require ../nexell-image-tiny.inc
inherit s5p4418-hs-iot-post-process

LICENSE = "LGPLv2.1"