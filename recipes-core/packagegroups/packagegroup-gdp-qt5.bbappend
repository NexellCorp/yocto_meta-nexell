RDEPENDS_${PN} = "\
    qtbase \
    qtbase-plugins \
    qtdeclarative \
    qtdeclarative-plugins \
    qtdeclarative-qmlplugins \
    qtquick1 \
    qtquick1-plugins \
    qtwayland \
    qtwayland-plugins \
    qtwebkit \
    qtwebkit-qmlplugins \
    qtgraphicaleffects-qmlplugins \
    "
 