SYSTEMD_DISABLED_SYSV_SERVICES = " \
    busybox-udhcpc \
    networking \
    nfsserver \
    nfscommon \
    syslog.busybox \
    dnsmasq \
    syslog \
    shr-splash \
    crond \
    keymap \
    fbsetup \
    populate-volatile \
    mountall \
    bootmisc \
    mountnfs \
    checkroot \
    fso-gpsd-sysv \
    gpsd-sysv \
"