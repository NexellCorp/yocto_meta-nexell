#Avoid task hash error message
PV = "1.3+snapshot"