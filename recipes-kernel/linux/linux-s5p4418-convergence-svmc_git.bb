require linux-s5p4418-convergence-svmc.inc

SRC_URI += "file://defconfig \
           "
