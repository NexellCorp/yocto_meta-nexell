require linux-s5p4418-daudio-cona.inc

SRC_URI += "file://defconfig \
           "
