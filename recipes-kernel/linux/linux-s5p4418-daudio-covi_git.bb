require linux-s5p4418-daudio-covi.inc

SRC_URI += "file://defconfig \
           "