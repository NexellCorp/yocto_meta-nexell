require linux-s5p4418-daudio-ref.inc

SRC_URI += "file://defconfig \
           "