require linux-s5p4418-ff-voice.inc

SRC_URI += "file://defconfig \
           "
