require linux-s5p4418-smart-voice.inc

SRC_URI += "file://defconfig \
            file://0001-Yocto-mali400-Kbuild-compile-error-fix.patch \
           "
