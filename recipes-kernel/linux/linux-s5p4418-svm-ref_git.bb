require linux-s5p4418-svm-ref.inc

SRC_URI += "file://defconfig \
           "