require linux-s5p6818-kick-st.inc

SRC_URI += "file://defconfig \
            file://0001-Yocto-mali400-Kbuild-compile-error-fix.patch \
           "
