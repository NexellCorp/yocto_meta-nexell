EXTRA_OECONF_append = " --enable-static"
FILES_${PN}-staticdev = "${libdir}/libpng.a ${libdir}/libpng16.a"
